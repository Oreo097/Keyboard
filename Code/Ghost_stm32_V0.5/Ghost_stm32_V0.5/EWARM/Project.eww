<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ghost_stm32_V0.5.ewp</path>
  </project>
  <batchBuild />
</workspace>
